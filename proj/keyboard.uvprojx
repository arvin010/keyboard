# Keil uVision project keyboard.uvprojx, settings and files
target Keyboard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FT32F072R8BTx FMD
  pack: FMD.FT32F0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: keyboard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F072x8
  c include: ..\FTLib\CMSIS\inc;..\FTLib\Inc;..\FTLib\Lib;..\usb\inc;..\user;..\RTT;..\iap2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: main.c keyboard.c SysTick.c io.c key_buffer.c Matrix.c
  group usb
    ../usb/src/: usb_core.c usb_desc.c
  group FTLib
    ../FTLib/Src/: ft32f0xx_adc.c ft32f0xx_comp.c ft32f0xx_crc.c ft32f0xx_crs.c ft32f0xx_dac.c ft32f0xx_debug.c ft32f0xx_dma.c ft32f0xx_exti.c ft32f0xx_flash.c ft32f0xx_gpio.c ft32f0xx_i2c.c ft32f0xx_iwdg.c ft32f0xx_misc.c ft32f0xx_opa.c ft32f0xx_pwr.c ft32f0xx_rcc.c ft32f0xx_rtc.c ft32f0xx_spi.c ft32f0xx_syscfg.c ft32f0xx_tim.c ft32f0xx_usart.c ft32f0xx_wwdg.c
    ../FTLib/Lib/: ft32f0xx_touch.lib
  group CMSIS
    ../FTLib/CMSIS/src/: system_ft32f0xx.c startup_ft32f072xb.s
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group iap2
    ../iap2/: SwTimer.c iAp2Session.c Iap2Link.c Iap2CtrlSession.c Driver.c ListUsbData.c List.c
